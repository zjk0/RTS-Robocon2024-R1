<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RTS_DJI_C.ewp</path>
  </project>
  <batchBuild />
</workspace>
