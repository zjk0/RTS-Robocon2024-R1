# IAR project RTS_bare_metal.ewp, settings and files
configuration RTS_bare_metal (ARM, debug)
  General.OGChipSelectEditMenu: STM32F427II ST STM32F427II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F427xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../USER/Inc; C:\Users\x'y'x\Desktop\???-2023-10-26\???-2023-10-26\???-2023-10-26\Core\Inc; C:\Users\x'y'x\Desktop\???-2023-10-26\???-2023-10-26\???-2023-10-26\Drivers\STM32F4xx_HAL_Driver\Inc; C:\Users\x'y'x\Desktop\???-2023-10-26\???-2023-10-26\???-2023-10-26\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; C:\Users\x'y'x\Desktop\???-2023-10-26\???-2023-10-26\???-2023-10-26\Drivers\CMSIS\Include; C:\Users\x'y'x\Desktop\???-2023-10-26\???-2023-10-26\???-2023-10-26\Drivers\CMSIS\Device\ST\STM32F4xx\Include; C:\Users\x'y'x\Desktop\???-2023-10-26\???-2023-10-26\???-2023-10-26\USER\Inc; C:\Users\x'y'x\Desktop\???-2023-10-26\???-2023-10-26\???-2023-10-26\Middlewares\Third_Party\FreeRTOS\Source\include; C:\Users\x'y'x\Desktop\???-2023-10-26\???-2023-10-26\???-2023-10-26\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2; C:\Users\x'y'x\Desktop\???-2023-10-26\???-2023-10-26\???-2023-10-26\Middlewares\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: RTS_bare_metal.hex
  ILINK.IlinkOutputFile: RTS_bare_metal.out
  ILINK.IlinkIcfFile: stm32f427xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group USER
    ../USER/Src/: ACTION.c CAN.c GM6030.c GO-M8010-6.c JY901.c LASER.c M3508.c PID.c RobotControl.c SBUS.c TSL1401.c USART.c
    ../USER/Inc/: TSL1401.h
