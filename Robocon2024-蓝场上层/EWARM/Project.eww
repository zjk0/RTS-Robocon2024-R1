<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RTS_bare_metal.ewp</path>
  </project>
  <batchBuild />
</workspace>
